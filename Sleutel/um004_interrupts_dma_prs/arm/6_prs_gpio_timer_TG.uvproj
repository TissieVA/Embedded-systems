# Keil uVision project 6_prs_gpio_timer_TG.uvproj, settings and files
target 6_prs_gpio_timer_TG (ARM-ADS)
  device: EFM32TG840F32 Energy Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: 6_prs_gpio_timer_TG
  AfterMake: fromelf.exe --bin --output obj\6_prs_gpio_timer_TG.bin obj\6_prs_gpio_timer_TG.axf
  c flags: Optim=1 oTime=1
  c define: EFM32TG840F32
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device/EnergyMicro/EFM32TG/Include;..\..\..\emlib\inc;..\..\..\kits\common\bsp;..\..\..\kits\common\drivers;..\..\..\kits\EFM32TG_STK3300\config
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../Device/EnergyMicro/EFM32TG/Source/ARM/: startup_efm32tg.s
    ../../../Device/EnergyMicro/EFM32TG/Source/: system_efm32tg.c
  group drivers
    ../../../kits/common/drivers/: segmentlcd.c
  group emlib
    ../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c em_lcd.c em_prs.c em_timer.c
  group Source Files
    ../: 6_prs_gpio_timer.c
