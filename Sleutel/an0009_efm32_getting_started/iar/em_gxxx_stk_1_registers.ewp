# IAR project em_gxxx_stk_1_registers.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32G890F128 Silicon Labs EFM32G890F128
  ICCARM.CCDefines: EFM32G890F128; STKG8XX
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32G\Include; ..\..\..\emlib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: em_gxxx_stk_1_registers.bin
  ILINK.IlinkOutputFile: em_gxxx_stk_1_registers.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32G890F128; STKG8XX
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32G/Source/IAR/: startup_efm32g.s
    ../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../emlib/src/: em_system.c
  group Source Files
    ../: 1_registers.c
