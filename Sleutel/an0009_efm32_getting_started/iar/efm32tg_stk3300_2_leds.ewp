# IAR project efm32tg_stk3300_2_leds.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: EFM32TG840F32 Silicon Labs EFM32TG840F32
  ICCARM.CCDefines: EFM32TG840F32; STK3300
  ICCARM.CCIncludePath2: ..\..\..\CMSIS\Include; ..\..\..\Device\SiliconLabs\EFM32TG\Include; ..\..\..\emlib\inc
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: efm32tg_stk3300_2_leds.bin
  ILINK.IlinkOutputFile: efm32tg_stk3300_2_leds.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; EFM32TG840F32; STK3300
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  group CMSIS
    ../../../Device/SiliconLabs/EFM32TG/Source/IAR/: startup_efm32tg.s
    ../../../Device/SiliconLabs/EFM32TG/Source/: system_efm32tg.c
  group emlib
    ../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c
  group Source Files
    ../: 2_leds.c
