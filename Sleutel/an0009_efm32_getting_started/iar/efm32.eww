<?xml version ="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\efm32zg_stk3200_1_registers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32zg_stk3200_2_leds.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32zg_stk3200_3_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32zg_stk3200_4_energymodes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32tg_stk3300_1_registers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32tg_stk3300_2_leds.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32tg_stk3300_3_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32tg_stk3300_4_energymodes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32gg_stk3700_1_registers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32gg_stk3700_2_leds.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32gg_stk3700_3_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\efm32gg_stk3700_4_energymodes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\em_gxxx_stk_1_registers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\em_gxxx_stk_2_leds.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\em_gxxx_stk_3_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\em_gxxx_stk_4_energymodes.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\em_gxxx_dk_1_registers.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\em_gxxx_dk_2_leds.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\em_gxxx_dk_3_lcd.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\em_gxxx_dk_4_energymodes.ewp</path>
  </project>

  <batchBuild/>
</workspace>
