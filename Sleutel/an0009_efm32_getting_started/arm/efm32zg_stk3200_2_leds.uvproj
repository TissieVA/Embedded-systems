# Keil uVision project efm32zg_stk3200_2_leds.uvproj, settings and files
target efm32zg_stk3200_2_leds (ARM-ADS)
  device: EFM32ZG222F32 Energy Micro
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(24000000) CPUTYPE("Cortex-M0+") ESEL ELITTLE
  output: efm32zg_stk3200_2_leds
  AfterMake: fromelf.exe --bin --output obj\efm32zg_stk3200_2_leds.bin obj\efm32zg_stk3200_2_leds.axf
  c flags: Optim=1 oTime=1
  c define: EFM32ZG222F32 STK3200
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32ZG\Include;..\..\..\emlib\inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32ZG/Source/ARM/: startup_efm32zg.s
    ../../../Device/SiliconLabs/EFM32ZG/Source/: system_efm32zg.c
  group emlib
    ../../../emlib/src/: em_assert.c em_system.c em_cmu.c em_emu.c em_gpio.c
  group Source Files
    ../: 2_leds.c
