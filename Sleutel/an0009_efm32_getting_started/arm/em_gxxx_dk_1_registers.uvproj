# Keil uVision project em_gxxx_dk_1_registers.uvproj, settings and files
target em_gxxx_dk_1_registers (ARM-ADS)
  device: EFM32G890F128 Energy Micro
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x1FFFF) CLOCK(14000000) CPUTYPE("Cortex-M3")
  output: em_gxxx_dk_1_registers
  AfterMake: fromelf.exe --bin --output obj\em_gxxx_dk_1_registers.bin obj\em_gxxx_dk_1_registers.axf
  c flags: Optim=1 oTime=1
  c define: EFM32G890F128
  c misc: --c99
  c include: ..\;..\..\..\CMSIS\Include;..\..\..\Device\SiliconLabs\EFM32G\Include;..\..\..\emlib\inc
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group CMSIS
    ../../../Device/SiliconLabs/EFM32G/Source/ARM/: startup_efm32g.s
    ../../../Device/SiliconLabs/EFM32G/Source/: system_efm32g.c
  group emlib
    ../../../emlib/src/: em_system.c
  group Source Files
    ../EFM32_Gxxx_DK/: 1_registers.c
